PACKAGECONFIG = "libpng eglfs gl gles2 accessibility freetype fontconfig jpeg evdev kms gbm dbus"
PACKAGECONFIG_remove = "x11 xcb xkb xkbcommon-evdev"
