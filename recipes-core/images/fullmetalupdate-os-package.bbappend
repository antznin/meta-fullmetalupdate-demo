# Copyright (C) 2019 Witekio
# Released under the MIT license (see COPYING.MIT for the terms)
include ${PN}_${MACHINE}.inc

IMAGE_INSTALL_append = " \
    fullmetalusers \
"
